## CMakeLists.txt
```
# SPDX-License-Identifier: Apache-2.0

cmake_minimum_required(VERSION 3.20.0)

find_package(Zephyr REQUIRED HINTS $ENV{ZEPHYR_BASE})
find_package(Python REQUIRED COMPONENTS Interpreter)

project(flowink)

target_sources(app PRIVATE
    app/app_main.c
    app/app_carousel.c
    app/app_mode.c
    app/show_picture.c
    component/btn.c
    component/epd.c
    component/led.c
    component/nv.c
    component/pwr_manage.c
    component/tf.c
    component/net/http_server.c
    component/net/wifi_ap_dhcp.c
    server/multi_button.c
    server/svc_bmp.c
)

if(CONFIG_LED_STRIP)
    target_sources(app PRIVATE component/rgb_strip.c)
endif()

target_include_directories(app PRIVATE
    ${CMAKE_CURRENT_SOURCE_DIR}/app
    ${CMAKE_CURRENT_SOURCE_DIR}/component
    ${CMAKE_CURRENT_SOURCE_DIR}/component/net
    ${CMAKE_CURRENT_SOURCE_DIR}/server
)

target_link_libraries(app PRIVATE zephyr_interface zephyr)

zephyr_linker_sources(SECTIONS ${CMAKE_CURRENT_SOURCE_DIR}/component/net/sections-rom.ld)
zephyr_linker_section(
  NAME http_resource_desc_http_service
  KVMA RAM_REGION GROUP RODATA_REGION
)

# 固定生成目录和读取目录
set(read_dir ${CMAKE_CURRENT_SOURCE_DIR}/resources/)
set(gen_dir ${ZEPHYR_BINARY_DIR}/include/generated/)

generate_inc_file_for_target(app
    ${read_dir}/build_in.bmp
    ${gen_dir}/build_in.bmp.inc
)

# 把需要嵌入固件的网页文件名写在这里
set(WEB_FILES
    index.html
    script.js
)

# 遍历变量内所有内容，‘&’取出变量值——变量file=变量值
foreach(file ${WEB_FILES})

# 读取一个二进制文件，压缩后转为 C 静态数组，生成 .inc 文件：固件；源文件路径；输出路径；转换前先压缩为gzip
generate_inc_file_for_target(app
    ${read_dir}/http/${file}
    ${gen_dir}/${file}.gz.inc
    --gzip
)

endforeach()

generate_inc_file_for_target(app
    ${read_dir}/http/zkk.png
    ${gen_dir}/zkk.png.inc
)
```

## Kconfig
```
# Copyright (c) 2019 Nordic Semiconductor ASA
# SPDX-License-Identifier: Apache-2.0

mainmenu "FlowInk Configuration"

config WAKEUP_TIME_SEC
	int "Wakeup time in seconds"
	default 180
	help
	  This option sets the time in seconds after which the device
	  will wake up from deep sleep. Defaults to 12 hours.

config LED_STRIP_BRIGHTNESS
	int "LED brightness"
	default 3
	range 1 255
	depends on CONFIG_LED_STRIP
	help
	  Brightness level of each LED. Defaults to a low value to make
	  it easier to distinguish colors.

menu "NET Configuration"

config WIFI_AP_SSID
	string "SSID of soft AP"
	help
	  SSID of the soft AP 
	  Fox example: "SOFT-AP"
	  
config WIFI_AP_PSK
	string "Pre-shared key for soft AP"
	help
	  WPA2 password used by the soft AP for client authentication.
	  For example: "PSK"

config WIFI_AP_IP_ADDRESS
	string "IP address of soft AP"
	help
	  IP address assigned to the soft AP interface.
	  For example: "192.168.4.1"

config WIFI_AP_NETMASK
	string "Netmask of soft AP"
	help
	  Subnet mask for the soft AP interface.
	  For example: "255.255.255.0"  

config HTTP_SERVER_SERVICE_PORT
	int "Port number for http service"
	default 80

endmenu

menu "EPD Configuration"

config EPD_PANEL_HEIGHT
	int "Height of the epd display screen"
	default 480

config EPD_PANEL_WIDTH
	int "Width of the epd display screen"
	default 800

config EPD_SEND_BUF_SIZE
	int "EPD send buffer size"
	default 192000
	help
	  Size of the buffer used to send data to the EPD display.

config BMP_ORIGINAL_SIZE
	int "BMP original size"
	default 1152054
	help
	  The original size of the BMP file.

endmenu

source "Kconfig.zephyr"
```

## prj.conf
```kconfig
CONFIG_SPI=y
CONFIG_LOG=y

CONFIG_INIT_STACKS=y
CONFIG_MAIN_STACK_SIZE=3072
CONFIG_SYSTEM_WORKQUEUE_STACK_SIZE=2048

CONFIG_ESP_SPIRAM=y
# 默认只有1MB
CONFIG_ESP_SPIRAM_HEAP_SIZE=3145728
CONFIG_SPIRAM_MODE_OCT=y
CONFIG_ESP32_WIFI_NET_ALLOC_SPIRAM=y
# 开了会系统崩溃
# CONFIG_ESP_WIFI_HEAP_SPIRAM=y

# ZVFS / Eventfd 文件抽象层
CONFIG_ZVFS=y
CONFIG_ZVFS_POLL_MAX=32
CONFIG_ZVFS_EVENTFD_MAX=2
CONFIG_ZVFS_EVENTFD=y
CONFIG_EVENTFD=y

# CONFIG_LED_STRIP=y
# CONFIG_LED_STRIP_LOG_LEVEL_OFF=y

CONFIG_POWEROFF=y
CONFIG_RETAINED_MEM=y

CONFIG_EVENTS=y
CONFIG_TEST_RANDOM_GENERATOR=y
CONFIG_SDHC=y
CONFIG_DISK_ACCESS=y
CONFIG_FILE_SYSTEM=y
CONFIG_FAT_FILESYSTEM_ELM=y
CONFIG_SD_LOG_LEVEL_OFF=y
# 不开启LFN的情况下，文件名长度最大为8.3（后缀名占3字符），且不支持中文
CONFIG_FS_FATFS_LFN=y
# 没有fatfs格式化的业务需求
CONFIG_FS_FATFS_MOUNT_MKFS=n

CONFIG_NETWORKING=y
CONFIG_NET_SOCKETS=y
CONFIG_NET_LOG=y
# IP 协议栈，暂不开启 ipv6
CONFIG_NET_IPV4=y
CONFIG_NET_IPV6=n
CONFIG_NET_IF_MAX_IPV4_COUNT=1
# CONFIG_NET_IF_MAX_IPV6_COUNT=2
# 协议
CONFIG_NET_TCP=y
# 网络缓冲区
CONFIG_NET_PKT_RX_COUNT=32
CONFIG_NET_PKT_TX_COUNT=32
CONFIG_NET_BUF_RX_COUNT=128
CONFIG_NET_BUF_TX_COUNT=128
CONFIG_NET_CONTEXT_NET_PKT_POOL=y
# 连接与上下文资源限制
CONFIG_NET_MAX_CONTEXTS=32
CONFIG_NET_MAX_CONN=32
# TCP 参数调优
# Required to handle large number of consecutive connections,
# e.g. when testing with ApacheBench.
CONFIG_NET_TCP_TIME_WAIT_DELAY=0
# 网络管理层 & 事件通知
CONFIG_NET_MGMT=y
CONFIG_NET_MGMT_EVENT=y
CONFIG_NET_MGMT_EVENT_INFO=y
CONFIG_NET_MGMT_EVENT_QUEUE_SIZE=10
CONFIG_NET_MGMT_EVENT_STACK_SIZE=4096
# 二层链路
CONFIG_NET_L2_ETHERNET=y
CONFIG_NET_L2_WIFI_MGMT=y
# 网络自动初始化与静态地址配置，请注意，该功能并非用于正式配置部署，仅适用于快速取样与测试。
CONFIG_NET_CONFIG_SETTINGS=y
# 自动初始化需要开启 CONFIG_NET_CONFIG_SETTINGS， If you do not wish to do this, then disable this and call net_config_init() in your application.
CONFIG_NET_CONFIG_AUTO_INIT=n
# 连接管理
CONFIG_NET_CONNECTION_MANAGER=y
# DHCPv4 服务端（AP 分配客户端IP）
CONFIG_NET_DHCPV4_SERVER=y
# 断连后释放 ip 的触发时间
CONFIG_NET_DHCPV4_SERVER_ADDR_LEASE_TIME=120
# 给自己申请ip
# CONFIG_NET_DHCPV4=y

CONFIG_WIFI=y
CONFIG_WIFI_NM=y
CONFIG_WIFI_ESP32=y
# 只开启 AP 模式
CONFIG_WIFI_USAGE_MODE_AP=y
# AP 参数
CONFIG_WIFI_AP_SSID="FlowInk-AP"
CONFIG_WIFI_AP_PSK="hhhhhhhh"
CONFIG_WIFI_AP_IP_ADDRESS="192.168.4.1"
CONFIG_WIFI_AP_NETMASK="255.255.255.0"

CONFIG_HTTP_PARSER=y
CONFIG_HTTP_PARSER_URL=y
CONFIG_HTTP_SERVER=y
CONFIG_HTTP_SERVER_VERSION_2=n
```

## flowink_esp32s3_procpu.overlay
```dts
&spi3 {
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";
	pinctrl-0 = <&spim3_default>;
	pinctrl-names = "default";

  /* sdhc-spi 需要软件 cs ！ */
	cs-gpios = <&gpio0 15 GPIO_ACTIVE_LOW>;

	sd: sd@0 {
		compatible = "zephyr,sdhc-spi-slot";
		reg = <0>;
		/* sd卡上下电延迟时间，让其充分稳定 */
		power-delay-ms = <2000>;
		/* SPI时钟，SD卡SPI最高推荐24MHz，不要直接上24M先从8M调试 */
		spi-max-frequency = <24000000>;

		/* 挂载到SD总线，接入到disk系统 */
		sdmmc {
			compatible = "zephyr,sdmmc-disk";
			disk-name = "SD";
		};
	};
};
```

## dts/bindings/epd_spi.yaml
```yaml
# Common fields for epd-spi(4 lines)
description: |
  Binding for the EPD (Electronic Paper Display) SPI device.

compatible: "nhf-um,epd-spi"

include: spi-device.yaml

properties:

  dc-gpios:
    type: phandle-array
    required: true
    description: |
      high when data is to be sent.

  rst-gpios:
    type: phandle-array
    required: true
    description: |
      low to reset the epd-display-ic.

  busy-gpios:
    type: phandle-array
    required: true
    description: |
      The busy GPIO should be pulled up.
```

## src/main.c
```c
#define LOG_LEVEL 4
#include <zephyr/logging/log.h>
LOG_MODULE_REGISTER(main);

#include <zephyr/kernel.h>
#include <zephyr/device.h>

int main(void)
{
    while (1) {

    }
    return 0;
}
```

## src/workq_common.c
```c
#include <zephyr/kernel.h>

#define WORK_QUEUE_STACK_SIZE 512
#define WORK_QUEUE_PRIORITY 5

K_THREAD_STACK_DEFINE(work_queue_stack, WORK_QUEUE_STACK_SIZE);

struct k_work_q work_queue;

void workq_init(void)
{
    k_work_queue_init(&work_queue);
    k_work_queue_start(&work_queue, work_queue_stack, K_THREAD_STACK_SIZEOF(work_queue_stack),
                       WORK_QUEUE_PRIORITY, NULL);
}
```
